Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-04-10T22:46:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 10 22:46:47 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{96D0B68F-DB7C-49AF-9660-AE6DDFD3A2E0}\ifc * Database version: 5507 * Database creation date: Fri Apr 10 22:46:46 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 10 22:46:47 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 10 22:46:47 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 57162219 Washbasin faucet, 6 V, Bluetooth, 57162219:57162219 Washbasin faucet, 6 V, Bluetooth:389528
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 168.484 mm; NominalHeight: 129.97 mm; NominalWidth: 66.2929 mm; Projection: 126 mm
Type - Electrical(Type) - Battery: Lithium 2CR5 6 V; Bluetooth: 4.x; Operating Voltage: 6 V; Protection Class: IP 55
Type - General(Type) - Author: Convergo AB; BIMObjectName: 57162219; ConvergoRefNr: 0087-2003-0040-FI; ManufacterURL: http://www.hansa.com/; ManufacturerName: Hansa; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 06/04/2020
Type - Green Building Properties(Type) - Backflow Prevention EN1717: AA; Customs Code: 84818011; EAN Number: 4057304014109; EMC Directive: 2014/30/EU; EN Standard: EN 15091
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.hansa.com/bim/57162219; Catalog Drawing URL: http://static.hansa.com/catdrw/57162219; Class: Touchless;Bluetooth®;Battery-operated; Dimension Drawing URL: http://static.hansa.com/dimdrw/57162219; FDV Document URL: http://www.hansa.com/datasheet/57162219/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/57162219; Group: Washbasin Faucets; Manufacturer: Hansa; Market: AUT;BEL;CZE;DEU;ESP;FRA;INT;ITA;NLD;SVK; Model: 57162219 Washbasin faucet, 6 V, Bluetooth; Name_en: 57162219 Washbasin faucet, 6 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 290 x 210 x 90; Package Weight: 2.031 kg; Product Code: 57162219; Product Datasheet: http://www.hansa.com/datasheet/57162219/en; Product Family: HANSASTELA; Product Image URL: http://static.hansa.com/image/57162219; Product URL: http://static.hansa.com/57162219; Type Name: 57162219 Washbasin faucet, 6 V, Bluetooth
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Adjustable settings (via bluetooth); Aerator: HONEYCOMB®; Afterflow Period: 3; Automatic Flush: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Connection: Flexible Inlet Pipes; Connection Size: G3/8; DN Size: DN15; Electronic Parts: Autofocus sensor;Solenoid valve;Low battery indication; Extensions: Rapid pop-up waste; Flow Rate At 300kPa With Flow Controller: 0.00353147 m3/s; Installation and Maintenance: http://static.hansa.com/manual/57162219; Installation Type: Deck mounted; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 120; Mechanical Parts: Litter filter(s);Mixing valve;Non-return valve(s); Mounting Holes: 1 Mounting Hole; Spare Parts: http://static.hansa.com/sp/57162219; Spout Type: Fixed spout; Temperature: Temperature limiter (retrofittable)
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Hansa; Category: Bathroom;Public & Semi-public; CodePerformance: n/a; Color: Chrome; Constituents: Single lever; DurationUnit: Year; ExpectedLife: n/a; Family Name: 57162219; Features: Touchless;Bluetooth®;Battery-operated; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 57162219; Name: 57162219 Washbasin faucet, 6 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 65x170x130 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 57162219; Manufacturer: Hansa
Pset_DistributionFlowElementCommon - Reference: 57162219 Washbasin faucet, 6 V, Bluetooth
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0429022 m2; Volume: 0.00146514 m3
Identity Data - Mark: 30
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 57162219: 57162219 Washbasin faucet, 6 V, Bluetooth; Family and Type: 57162219: 57162219 Washbasin faucet, 6 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 57162219: 57162219 Washbasin faucet, 6 V, Bluetooth; Type Id: 57162219: 57162219 Washbasin faucet, 6 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
